Commit message: sync

File: src/unitree_ros2_sim/go1_sim/go1_description/urdf/go1.urdf (robot description, URDF)
Before this commit: robot go1, 47 links, 46 joints
Links:
- link FL_foot: mass 0.06 -> None
